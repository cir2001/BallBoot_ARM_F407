# Keil uVision project BallBot_Arm_F407.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BallBot_F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: .\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\LCD;.\HARDWARE\MPU6050;.\HARDWARE\SPI;.\HARDWARE\TIMER;.\HARDWARE\KEY;.\HARDWARE\LED;.\HARDWARE\MPU6500\eMPL;.\HARDWARE\MPU6500;.\HARDWARE\EXTI;.\HARDWARE\TIMER;.\HARDWARE\CAN;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\portable\MenMang;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\HARDWARE\OLED;.\HARDWARE\DMA;.\AHRS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./USER/: startup_stm32f40_41xxx.s
    ./SYSTEM/sys/: system_stm32f4xx.h
  group USER
    ./USER/: BallBot_Arm.c
  group SYSTEM
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c system_stm32f4xx.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/SPI/: spi.c
    ./HARDWARE/MPU6500/: mpu6500_driver.c mpuiic.c
    ./HARDWARE/EXTI/: exti.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/CAN/: can.c
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/DMA/: dma_driver.c
  group MPU DMP
    ./HARDWARE/MPU6500/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./HARDWARE/MPU6500/: math_fun.c
  group freeRTOS/core
    ./FreeRTOS/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c stream_buffer.c tasks.c timers.c
  group freeRTOS/include
    ./FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h portmacro.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freeRTOS/RVDS/ARM_CM4F
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group freeRTOS/MenMang
    ./FreeRTOS/portable/MenMang/: heap_4.c
  group AHRS
    ./AHRS/: mahony.h mahony.c
software components: CMSIS:CORE 5.4.0
